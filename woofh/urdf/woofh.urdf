Commit message: 补偿了角度差值，现在四脚可以同时落地了

File: woofh/urdf/woofh.urdf (robot description, URDF)
Before this commit: robot Urdf_trail_2, 23 links, 22 joints
Links:
- link base_link: mass 0.24680316805231461 -> 2.0
